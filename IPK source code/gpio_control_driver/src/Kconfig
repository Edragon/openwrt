## IPK source code/gpio_control_driver/src/Kconfig
```kconfig
config GPIO_CONTROL_DRIVER
        tristate "Gpio control driver for JS9331 and JS7628"
        depends on GENERIC_GPIO
```
